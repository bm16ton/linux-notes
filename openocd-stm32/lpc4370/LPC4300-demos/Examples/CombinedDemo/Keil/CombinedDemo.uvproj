# Keil uVision project CombinedDemo.uvproj, settings and files
target LPC4350_IntSRAM (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: CM4
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf -c --output="$L@L.my.list" "$L@L.axf"
  c flags: Optim=2
  c define: CORE_M4
  c include: ..\;..\..\..\Core\CMSIS\Include;..\..\..\Core\Device\NXP\lpc43xx\Include;..\..\..\Drivers\include;..\..\..\Boards
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10018000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group CMSIS_CM4
    ../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group Drivers
    ../../../Drivers/source/: lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_rgu.c lpc43xx_scu.c
    ../../../Boards/: lpc4350_db1_emc.c
  group Startup
    ../../../Core/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
  group easyweb
    ../easyweb/: emac.c tcpip.c
  group Source
    ../: hid_usbdesc.c main.c usbd_hid.c
target LPC4350_ExtFLASH (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: CM4
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf -c --output="$L@L.my.list" "$L@L.axf"
  c flags: Optim=2
  c define: CORE_M4
  c include: ..\; ..\..\..\Core\CMSIS\Include; ..\..\..\Core\Device\NXP\lpc43xx\Include; ..\..\..\Drivers\include; ..\..\..\Boards
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1c000000 size 0x200000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC4357_IntSRAM (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: CM4
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf -c --output="$L@L.my.list" "$L@L.axf"
  c flags: Optim=2
  c define: CORE_M4
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC4357_ExtFLASH (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: CM4
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf -c --output="$L@L.my.list" "$L@L.axf"
  c flags: Optim=2
  c define: CORE_M4
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1c000000 size 0x200000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC4357_IntFLASH (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: CM4
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=2
  c define: CORE_M4 INTERNAL_FLASH
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
